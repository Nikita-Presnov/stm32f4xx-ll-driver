<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Code</name>
    <file>
      <name>$PROJ_DIR$\Source\stm32f4xx_ll_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\stm32f4xx_ll_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\stm32f4xx_ll_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\stm32f4xx_ll_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\stm32f4xx_ll_dma2d.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\stm32f4xx_ll_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\stm32f4xx_ll_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\stm32f4xx_ll_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\stm32f4xx_ll_irq.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\stm32f4xx_ll_lptim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\stm32f4xx_ll_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\stm32f4xx_ll_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\stm32f4xx_ll_rng.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\stm32f4xx_ll_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\stm32f4xx_ll_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\stm32f4xx_ll_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\stm32f4xx_ll_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\stm32f4xx_ll_utils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\system_stm32f4xx.c</name>
    </file>
  </group>
</project>


